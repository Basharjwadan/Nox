Commit message: modified robot descripton

File: nox_description/urdf/nox.urdf (robot description, URDF)
Before this commit: robot nox, 2 links, 1 joints
Joints:
- joint base_link_to_laser: origin xyz=0.0 0.0 0.3 rpy=0.0 0.0 3.141592 -> xyz=0.0 0.0 0.3 rpy=0.0 0.0 0.0
